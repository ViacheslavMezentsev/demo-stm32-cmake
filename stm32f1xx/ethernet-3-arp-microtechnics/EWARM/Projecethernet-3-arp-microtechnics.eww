<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ethernet-3-arp-microtechnics.ewp</path>
  </project>
  <batchBuild />
</workspace>
