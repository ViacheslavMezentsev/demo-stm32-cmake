<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ethernet-1-enc28j60-microtechnics.ewp</path>
  </project>
  <batchBuild />
</workspace>
