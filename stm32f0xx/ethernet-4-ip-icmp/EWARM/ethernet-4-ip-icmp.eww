<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ethernet-4-ip-icmp.ewp</path>
  </project>
  <batchBuild />
</workspace>
